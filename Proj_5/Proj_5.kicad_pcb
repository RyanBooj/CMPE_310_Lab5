# Repository RyanBooj/CMPE_310_Lab5 (continued)

## KiCad design Proj_5/Proj_5.kicad_pcb (continued)

Parts:
C14: 0.1uF
C21: 100uF
J6: Conn_02x30_Top_Bottom
J8: Conn_01x02
U19: 8086_Min_Mode; DIP-40_W15.24mm
U20, U21, U23: 74LS373
U22: 74LS244
U24, U25: 74LS245

Connections:
/8086 and Demultiplexed Addresses/CLK: U19.19 (CLK); also elsewhere on the board
/8279, 8259, 8254/INT: J6.10, U19.18 (INTR); also elsewhere on the board
/8279, 8259, 8254/NMI: U19.17 (NMI); also elsewhere on the board
/8279, 8259, 8254/~INTA: J6.12, U22.12 (O3a); also elsewhere on the board
/16550 UART/RESET: U19.21 (RESET); also elsewhere on the board
/A0: U23.19 (O7); also elsewhere on the board
/A1: U23.16 (O6); also elsewhere on the board
/A2: U23.15 (O5); also elsewhere on the board
/A3: U23.12 (O4); also elsewhere on the board
/A4: U23.9 (O3); also elsewhere on the board
/A5: U23.6 (O2); also elsewhere on the board
/A6: U23.5 (O1); also elsewhere on the board
/A7: U23.2 (O0); also elsewhere on the board
/A8: U21.19 (O7); also elsewhere on the board
/A9: U21.16 (O6); also elsewhere on the board
/A10: U21.15 (O5); also elsewhere on the board
/A11: U21.12 (O4); also elsewhere on the board
/A12: U21.9 (O3); also elsewhere on the board
/A13: U21.6 (O2); also elsewhere on the board
/A14: U21.5 (O1); also elsewhere on the board
/A15: U21.2 (O0); also elsewhere on the board
/A16: U20.12 (O4); also elsewhere on the board
/A17: U20.9 (O3); also elsewhere on the board
/A18: U20.6 (O2); also elsewhere on the board
/A19: U20.5 (O1); also elsewhere on the board
/D0: U24.11 (B7); also elsewhere on the board
/D1: U24.12 (B6); also elsewhere on the board
/D2: U24.13 (B5); also elsewhere on the board
/D3: U24.14 (B4); also elsewhere on the board
/D4: U24.15 (B3); also elsewhere on the board
/D5: U24.16 (B2); also elsewhere on the board
/D6: U24.17 (B1); also elsewhere on the board
/D7: U24.18 (B0); also elsewhere on the board
/D8: U25.11 (B7); also elsewhere on the board
/D9: U25.12 (B6); also elsewhere on the board
/D10: U25.13 (B5); also elsewhere on the board
/D11: U25.14 (B4); also elsewhere on the board
/D12: U25.15 (B3); also elsewhere on the board
/D13: U25.16 (B2); also elsewhere on the board
/D14: U25.17 (B1); also elsewhere on the board
/D15: U25.18 (B0); also elsewhere on the board
/M~IO: J6.9, U22.18 (O0a); also elsewhere on the board
/~BHE: U20.2 (O0); also elsewhere on the board
/~RD: J6.7, U22.14 (O2a); also elsewhere on the board
/~WR: J6.8, U22.16 (O1a); also elsewhere on the board
GND: C14.1, C21.1, J8.1, U19.1 (GND), U19.20 (GND), U20.1 (OE), U20.10 (GND), U21.1 (OE), U21.10 (GND), U22.1 (OEa), U22.10 (GND), U23.1 (OE), U23.10 (GND), U24.10 (GND), U25.10 (GND); also elsewhere on the board
unnamed: J6.1, U19.27 (DT/~R~), U24.1 (A->B), U25.1 (A->B)
unnamed: J6.2, U19.26 (~DEN~), U24.19 (CE), U25.19 (CE)
unnamed: J6.3, U19.25 (ALE), U20.11 (LE), U21.11 (LE), U23.11 (LE)
unnamed: J6.11, U19.22 (READY)
unnamed: U19.2 (AD14), U21.4 (D1), U25.3 (A1)
unnamed: U19.3 (AD13), U21.7 (D2), U25.4 (A2)
unnamed: U19.4 (AD12), U21.8 (D3), U25.5 (A3)
unnamed: U19.5 (AD11), U21.13 (D4), U25.6 (A4)
unnamed: U19.6 (AD10), U21.14 (D5), U25.7 (A5)
unnamed: U19.7 (AD9), U21.17 (D6), U25.8 (A6)
unnamed: U19.8 (AD8), U21.18 (D7), U25.9 (A7)
unnamed: U19.9 (AD7), U23.3 (D0), U24.2 (A0)
unnamed: U19.10 (AD6), U23.4 (D1), U24.3 (A1)
unnamed: U19.11 (AD5), U23.7 (D2), U24.4 (A2)
unnamed: U19.12 (AD4), U23.8 (D3), U24.5 (A3)
unnamed: U19.13 (AD3), U23.13 (D4), U24.6 (A4)
unnamed: U19.14 (AD2), U23.14 (D5), U24.7 (A5)
unnamed: U19.15 (AD1), U23.17 (D6), U24.8 (A6)
unnamed: U19.16 (AD0), U23.18 (D7), U24.9 (A7)
unnamed: U19.24 (~INTA~), U22.8 (I3a)
unnamed: U19.28 (M/~IO~), U22.2 (I0a)
unnamed: U19.29 (~WR~), U22.4 (I1a)
unnamed: U19.32 (~RD~), U22.6 (I2a)
unnamed: U19.34 (~BHE~/S7), U20.3 (D0)
unnamed: U19.35 (A19/S6), U20.4 (D1)
unnamed: U19.36 (A18/S5), U20.7 (D2)
unnamed: U19.37 (A17/S4), U20.8 (D3)
unnamed: U19.38 (A16/S3), U20.13 (D4)
unnamed: U19.39 (AD15), U21.3 (D0), U25.2 (A0)

Parts:
C10, C20: 0.1uF
J7: DSUB-9
R18: 1K
U14: 16550; DIP-40_W15.24mm
U51, U52: PAL16L8
U55: max235cpg

Connections:
/8086 and Demultiplexed Addresses/CLK: U14.9 (RCLK); also elsewhere on the board
/16550 UART/IR3: U14.30 (INTR); also elsewhere on the board
/16550 UART/RESET: U14.35 (MR); also elsewhere on the board
/A0: U51.8 (I8); also elsewhere on the board
/A1: U14.28 (A0), U51.7 (I7); also elsewhere on the board
/A2: U14.27 (A1), U51.6 (I6); also elsewhere on the board
/A3: U14.26 (A2), U51.5 (I5); also elsewhere on the board
/A4: U51.4 (I4); also elsewhere on the board
/A5: U51.3 (I3); also elsewhere on the board
/A6: U51.2 (I2); also elsewhere on the board
/A7: U51.1 (I1); also elsewhere on the board
/A8: U52.17 (I03); also elsewhere on the board
/A9: U52.18 (IO2); also elsewhere on the board
/A10: U52.11 (I10); also elsewhere on the board
/A11: U52.9 (I9); also elsewhere on the board
/A12: U52.8 (I8); also elsewhere on the board
/A13: U52.7 (I7); also elsewhere on the board
/A14: U52.6 (I6); also elsewhere on the board
/A15: U52.5 (I5); also elsewhere on the board
/A16: U52.4 (I4); also elsewhere on the board
/A17: U52.3 (I3); also elsewhere on the board
/A18: U52.2 (I2); also elsewhere on the board
/A19: U52.1 (I1); also elsewhere on the board
/D8: U14.1 (D0); also elsewhere on the board
/D9: U14.2 (D1); also elsewhere on the board
/D10: U14.3 (D2); also elsewhere on the board
/D11: U14.4 (D3); also elsewhere on the board
/D12: U14.5 (D4); also elsewhere on the board
/D13: U14.6 (D5); also elsewhere on the board
/D14: U14.7 (D6); also elsewhere on the board
/D15: U14.8 (D7); also elsewhere on the board
/~RD: U14.21 (~RD~); also elsewhere on the board
/~WR: U14.18 (~WR~); also elsewhere on the board
GND: C10.1, C20.2, J7.5 (GND), U14.20 (GND), U14.25 (~ADS~), U51.10 (GND), U52.10 (GND), U55.11 (GND), U55.20 (*EN); also elsewhere on the board
unnamed: J7.1 (DCD), U14.38 (~DCD~)
unnamed: J7.2 (RXD), U55.24 (R3IN)
unnamed: J7.3 (TXD), U55.3 (T1OUT)
unnamed: J7.4 (DTR), U14.33 (~DTR~)
unnamed: J7.6 (DSR), U14.37 (~DSR~)
unnamed: J7.7 (RTS), U14.32 (~RTS~)
unnamed: J7.8 (CTS), U14.36 (~CTS~)
unnamed: U14.10 (SIN), U55.23 (R3OUT)
unnamed: U14.11 (SOUT), U55.8 (T1IN)
unnamed: U51.11 (I10), U52.19 (IO1)

Parts:
C22: 0.1uF; CP_EIA-1608-08_AVX-J
DS1: LCD4x20; Mouser Part Number 763-0420AZFLYBW33V3
U15, U16: PAL16L8; DIP-20_W7.62mm

Connections:
/A0: U16.8 (I8); also elsewhere on the board
/A1: U16.7 (I7); also elsewhere on the board
/A2: U16.6 (I6); also elsewhere on the board
/A3: U16.5 (I5); also elsewhere on the board
/A4: U16.4 (I4); also elsewhere on the board
/A5: U16.3 (I3); also elsewhere on the board
/A6: U16.2 (I2); also elsewhere on the board
/A7: U16.1 (I1); also elsewhere on the board
/A8: U15.14 (IO6); also elsewhere on the board
/A9: U15.13 (IO7); also elsewhere on the board
/A10: U15.11 (I10); also elsewhere on the board
/A11: U15.9 (I9); also elsewhere on the board
/A12: U15.8 (I8); also elsewhere on the board
/A13: U15.7 (I7); also elsewhere on the board
/A14: U15.6 (I6); also elsewhere on the board
/A15: U15.5 (I5); also elsewhere on the board
/A16: U15.4 (I4); also elsewhere on the board
/A17: U15.3 (I3); also elsewhere on the board
/A18: U15.2 (I2); also elsewhere on the board
/A19: U15.1 (I1); also elsewhere on the board
/D0: DS1.7 (DB0); also elsewhere on the board
/D1: DS1.8 (DB1); also elsewhere on the board
/D2: DS1.9 (DB2); also elsewhere on the board
/D3: DS1.10 (DB3); also elsewhere on the board
/D4: DS1.11 (DB4); also elsewhere on the board
/D5: DS1.12 (DB5); also elsewhere on the board
/D6: DS1.13 (DB6); also elsewhere on the board
/D7: DS1.14 (DB7); also elsewhere on the board
GND: C22.2, DS1.1 (VSS), DS1.3 (V0), U15.10 (GND), U16.10 (GND); also elsewhere on the board
unnamed: DS1.4 (RS), U16.19 (IO1)
unnamed: DS1.5 (R/W), U16.18 (IO2)
unnamed: DS1.6 (E), U16.17 (I03)
unnamed: U15.12 (IO8), U16.9 (I9)

Schematic: LED_Switch.sch

Parts:
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_D3.0mm_FlatTop
R1, R2, R3, R4, R5, R6, R7, R8: 10kOhm; R_1206_3216Metric
R9, R10, R11, R12, R13, R14, R15, R16, R19: 1kOhm; R_1206_3216Metric
SW1: SW_DIP_x08; SW_DIP_SPSTx08_Slide_Copal_CHS-08A_W5.08mm_P1.27mm_JPin
U33, U36, U56: 74LS374; DIP-20_W7.62mm
U34, U37: MAN72A
U57: 74LS244; DIP-20_W7.62mm
U59, U61: PAL16L8; DIP-20_W7.62mm

Connections:
/8086 and Demultiplexed Addresses/CLK: U33.11 (Cp), U36.11 (Cp), U56.11 (Cp); also elsewhere on the board
/A0: U59.1 (I1); also elsewhere on the board
/A1: U59.2 (I2); also elsewhere on the board
/A2: U59.3 (I3); also elsewhere on the board
/A3: U59.4 (I4); also elsewhere on the board
/A4: U61.13 (IO7); also elsewhere on the board
/A5: U61.14 (IO6); also elsewhere on the board
/A6: U61.15 (IO5); also elsewhere on the board
/A7: U61.16 (IO4); also elsewhere on the board
/A8: U61.17 (I03); also elsewhere on the board
/A9: U61.18 (IO2); also elsewhere on the board
/A10: U61.11 (I10); also elsewhere on the board
/A11: U61.9 (I9); also elsewhere on the board
/A12: U61.8 (I8); also elsewhere on the board
/A13: U61.7 (I7); also elsewhere on the board
/A14: U61.6 (I6); also elsewhere on the board
/A15: U61.5 (I5); also elsewhere on the board
/A16: U61.4 (I4); also elsewhere on the board
/A17: U61.3 (I3); also elsewhere on the board
/A18: U61.2 (I2); also elsewhere on the board
/A19: U61.1 (I1); also elsewhere on the board
/D0: U33.3 (D0), U36.3 (D0), U56.3 (D0), U57.18 (O0a); also elsewhere on the board
/D1: U33.4 (D1), U36.4 (D1), U56.4 (D1), U57.16 (O1a); also elsewhere on the board
/D2: U33.7 (D2), U36.7 (D2), U56.7 (D2), U57.14 (O2a); also elsewhere on the board
/D3: U33.8 (D3), U36.8 (D3), U56.8 (D3), U57.12 (O3a); also elsewhere on the board
/D4: U33.13 (D4), U36.13 (D4), U56.13 (D4), U57.9 (O0b); also elsewhere on the board
/D5: U33.14 (D5), U36.14 (D5), U56.14 (D5), U57.7 (O1b); also elsewhere on the board
/D6: U33.17 (D6), U36.17 (D6), U56.17 (D6), U57.5 (O2b); also elsewhere on the board
/D7: U33.18 (D7), U36.18 (D7), U56.18 (D7), U57.3 (O3b); also elsewhere on the board
GND: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, U33.10 (GND), U36.10 (GND), U56.10 (GND), U57.10 (GND), U59.10 (GND), U61.10 (GND); also elsewhere on the board
unnamed: D1.2 (A), R9.1
unnamed: D2.2 (A), R10.1
unnamed: D3.2 (A), R11.1
unnamed: D4.2 (A), R12.1
unnamed: D5.2 (A), R13.1
unnamed: D6.2 (A), R14.1
unnamed: D7.2 (A), R15.1
unnamed: D8.2 (A), R16.1
unnamed: R1.2, SW1.16, U57.2 (I0a)
unnamed: R2.2, SW1.15, U57.4 (I1a)
unnamed: R3.2, SW1.14, U57.6 (I2a)
unnamed: R4.2, SW1.13, U57.8 (I3a)
unnamed: R5.2, SW1.12, U57.11 (I0b)
unnamed: R6.2, SW1.11, U57.13 (I1b)
unnamed: R7.2, SW1.10, U57.15 (I2b)
unnamed: R8.2, SW1.9, U57.17 (I3b)
unnamed: R9.2, U56.2 (O0)
unnamed: R10.2, U56.5 (O1)
unnamed: R11.2, U56.6 (O2)
unnamed: R12.2, U56.9 (O3)
unnamed: R13.2, U56.12 (O4)
unnamed: R14.2, U56.15 (O5)
unnamed: R15.2, U56.16 (O6)
unnamed: R16.2, U56.19 (O7)
unnamed: R19.2, U34.3 (CA), U34.14 (CA), U37.3 (CA), U37.14 (CA)
unnamed: U33.1 (OE), U59.18 (IO2)
unnamed: U33.2 (O0), U34.1 (A)
unnamed: U33.5 (O1), U34.13 (B)
unnamed: U33.6 (O2), U34.10 (C)
unnamed: U33.9 (O3), U34.8 (D)
unnamed: U33.12 (O4), U34.7 (E)
unnamed: U33.15 (O5), U34.2 (F)
unnamed: U33.16 (O6), U34.11 (G)
unnamed: U33.19 (O7), U34.6 (D.P.)
unnamed: U36.1 (OE), U59.17 (I03)
unnamed: U36.2 (O0), U37.1 (A)
unnamed: U36.5 (O1), U37.13 (B)
unnamed: U36.6 (O2), U37.10 (C)
unnamed: U36.9 (O3), U37.8 (D)
unnamed: U36.12 (O4), U37.7 (E)
unnamed: U36.15 (O5), U37.2 (F)
unnamed: U36.16 (O6), U37.11 (G)
unnamed: U36.19 (O7), U37.6 (D.P.)
unnamed: U56.1 (OE), U59.16 (IO4)
unnamed: U57.1 (OEa), U57.19 (OEb), U59.19 (IO1)
unnamed: U59.9 (I9), U61.19 (IO1)

Schematic: CY7C199.sch

Parts:
C1, C3, C4, C5, C6: 0.1uF; CP_EIA-1608-08_AVX-J
U5, U6, U8, U9: CY7C199; DIP-28_W15.24mm
U7: PAL16L8; DIP-20_W7.62mm

Connections:
/A0: U5.21 (A0), U6.21 (A0), U8.21 (A0), U9.21 (A0); also elsewhere on the board
/A1: U5.23 (A1), U6.23 (A1), U8.23 (A1), U9.23 (A1); also elsewhere on the board
/A2: U5.24 (A2), U6.24 (A2), U8.24 (A2), U9.24 (A2); also elsewhere on the board
/A3: U5.25 (A3), U6.25 (A3), U8.25 (A3), U9.25 (A3); also elsewhere on the board
/A4: U5.26 (A4), U6.26 (A4), U8.26 (A4), U9.26 (A4); also elsewhere on the board
/A5: U5.1 (A5), U6.1 (A5), U8.1 (A5), U9.1 (A5); also elsewhere on the board
/A6: U5.2 (A6), U6.2 (A6), U8.2 (A6), U9.2 (A6); also elsewhere on the board
/A7: U5.3 (A7), U6.3 (A7), U8.3 (A7), U9.3 (A7); also elsewhere on the board
/A8: U5.4 (A8), U6.4 (A8), U8.4 (A8), U9.4 (A8); also elsewhere on the board
/A9: U5.5 (A9), U6.5 (A9), U8.5 (A9), U9.5 (A9); also elsewhere on the board
/A10: U5.6 (A10), U6.6 (A10), U8.6 (A10), U9.6 (A10); also elsewhere on the board
/A11: U5.7 (A11), U6.7 (A11), U8.7 (A11), U9.7 (A11); also elsewhere on the board
/A12: U5.8 (A12), U6.8 (A12), U8.8 (A12), U9.8 (A12); also elsewhere on the board
/A13: U5.9 (A13), U6.9 (A13), U8.9 (A13), U9.9 (A13); also elsewhere on the board
/A14: U5.10 (A14), U6.10 (A14), U8.10 (A14), U9.10 (A14); also elsewhere on the board
/A15: U7.5 (I5); also elsewhere on the board
/A16: U7.4 (I4); also elsewhere on the board
/A17: U7.3 (I3); also elsewhere on the board
/A18: U7.2 (I2); also elsewhere on the board
/A19: U7.1 (I1); also elsewhere on the board
/D0: U5.11 (D0), U6.11 (D0); also elsewhere on the board
/D1: U5.12 (D1), U6.12 (D1); also elsewhere on the board
/D2: U5.13 (D2), U6.13 (D2); also elsewhere on the board
/D3: U5.15 (D3), U6.15 (D3); also elsewhere on the board
/D4: U5.16 (D4), U6.16 (D4); also elsewhere on the board
/D5: U5.17 (D5), U6.17 (D5); also elsewhere on the board
/D6: U5.18 (D6), U6.18 (D6); also elsewhere on the board
/D7: U5.19 (D7), U6.19 (D7); also elsewhere on the board
/D8: U8.11 (D0), U9.11 (D0); also elsewhere on the board
/D9: U8.12 (D1), U9.12 (D1); also elsewhere on the board
/D10: U8.13 (D2), U9.13 (D2); also elsewhere on the board
/D11: U8.15 (D3), U9.15 (D3); also elsewhere on the board
/D12: U8.16 (D4), U9.16 (D4); also elsewhere on the board
/D13: U8.17 (D5), U9.17 (D5); also elsewhere on the board
/D14: U8.18 (D6), U9.18 (D6); also elsewhere on the board
/D15: U8.19 (D7), U9.19 (D7); also elsewhere on the board
/M~IO: U7.7 (I7); also elsewhere on the board
/~BHE: U7.6 (I6); also elsewhere on the board
/~RD: U5.22 (~OE~), U6.22 (~OE~), U8.22 (~OE~), U9.22 (~OE~); also elsewhere on the board
/~WR: U5.27 (~WE~), U6.27 (~WE~), U8.27 (~WE~), U9.27 (~WE~); also elsewhere on the board
GND: C1.1, C3.1, C4.1, C5.1, C6.1, U5.14 (GND), U6.14 (GND), U7.10 (GND), U8.14 (GND), U9.14 (GND); also elsewhere on the board
unnamed: U5.20 (~CE~), U7.16 (IO4)
unnamed: U6.20 (~CE~), U7.17 (I03)
unnamed: U7.18 (IO2), U9.20 (~CE~)
unnamed: U7.19 (IO1), U8.20 (~CE~)

Notes on the sheet:
Low Bank
High Bank

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
Board: 4 copper layers, 717.5 x 762.0 mm, 132 parts (0 on the bottom side), 264 nets.

Other parts of the board:
J9: Conn_02x16_Counter_Clockwise; PinHeader_2x16_P2.54mm_Vertical
J10: Conn_02x20_Counter_Clockwise; PinHeader_2x20_P2.54mm_Vertical

Their connections:
/A0: J10.1; also elsewhere on the board
/A1: J10.2; also elsewhere on the board
/A2: J10.3; also elsewhere on the board
/A3: J10.4; also elsewhere on the board
/A4: J10.5; also elsewhere on the board
/A5: J10.6; also elsewhere on the board
/A6: J10.7; also elsewhere on the board
/A7: J10.8; also elsewhere on the board
/A8: J10.9; also elsewhere on the board
/A9: J10.10; also elsewhere on the board
/A10: J10.11; also elsewhere on the board
/A11: J10.12; also elsewhere on the board
/A12: J10.13; also elsewhere on the board
/A13: J10.14; also elsewhere on the board
/A14: J10.15; also elsewhere on the board
/A15: J10.16; also elsewhere on the board
/A16: J10.17; also elsewhere on the board
/A17: J10.18; also elsewhere on the board
/A18: J10.19; also elsewhere on the board
/A19: J10.20; also elsewhere on the board
/D0: J9.1; also elsewhere on the board
/D1: J9.2; also elsewhere on the board
/D2: J9.3; also elsewhere on the board
/D3: J9.4; also elsewhere on the board
/D4: J9.5; also elsewhere on the board
/D5: J9.6; also elsewhere on the board
/D6: J9.7; also elsewhere on the board
/D7: J9.8; also elsewhere on the board
/D8: J9.9; also elsewhere on the board
/D9: J9.10; also elsewhere on the board
/D10: J9.11; also elsewhere on the board
/D11: J9.12; also elsewhere on the board
/D12: J9.13; also elsewhere on the board
/D13: J9.14; also elsewhere on the board
/D14: J9.15; also elsewhere on the board
/D15: J9.16; also elsewhere on the board
/~BHE: J10.21; also elsewhere on the board

## Commit log

2020-04-10 Added Project files
2020-04-10 Test Changes
2020-04-10 Test Push
2020-04-10 Added 8087 to Proj5 schematic
2020-04-10 deleted confusion
2020-04-10 Added Address Bus
2020-04-10 Added Power to 8087
2020-04-16 Added missing parts and stuff
2020-04-17 Cleaning
2020-04-17 Added a clock circuit
2020-04-17 Added Schematics, finish SRAM and 8279
2020-04-21 Placed 8086 in own Sheet
2020-04-21 new Sheets
2020-04-22 Buffered and Demultiplexed Address/Data Bus
2020-04-22 Please work
2020-04-22 Progress on 8279
2020-04-22 Moved Files around in top file, added sheet for display and LEDs
2020-04-22 Labeled Data Bus and Address bus wires in CMOS
2020-04-22 Added address decoding
2020-04-22 Added some connections; Some connections are reporting 'No connections' and IDK why
2020-04-22 Updated doc: CMOS info
2020-04-22 Fixed CMOS and connected to processor. Still missing some pins though
2020-04-22 Please dont break
2020-04-22 also no
2020-04-22 Help
2020-04-22 Added Caps to Each Vcc per desc.
2020-04-22 Changed Addressing Again
2020-04-22 Dinner Break
2020-04-22 Removed 59 and 54 Ind. Sheets, moved to 8279
2020-04-22 Dont be wonky:
2020-04-23 Made a rats nest in 8255.sch
2020-04-23 Mostly finished 8279
2020-04-23 Test
2020-04-23 Quick Edit to 79 Wires
2020-04-23 Made the rest of the connections for the SRAM. Changed stuff on the main page
2020-04-23 Sick wires bro
2020-04-23 Changes to Top Level Connections
2020-04-23 LCD boop
2020-04-23 Rerouted Ext Wires, UART Mostly Complete, All Headers Added
2020-04-23 Monch
2020-04-24 Remaining LED Components Added, Final pins added to headers.
2020-05-04 Small changes to component placements.
2020-05-04 Added Power Flags, finished no connects.
2020-05-04 Finished Most of power flags, power connector header, added hierachical pins to a few sheets.
2020-05-05 Power Flags
2020-05-05 Addressing for 8279 and 8259
2020-05-06 Destroyed errors
2020-05-06 11 errors left
2020-05-06 1 Error Remains
2020-05-06 Last error destroyed
2020-05-06 Added 5 Footprints
2020-05-08 Added at least 4 Footprints
2020-05-08 No more and gates
2020-05-08 No more gates 2
2020-05-08 Scary
2020-05-08 Playing with PCB placements
2020-05-08 Hey Collin
2020-05-08 Cool stuff
2020-05-09 Bus time
2020-05-09 Keyboard + Individual LEDS
2020-05-09 Complete Data Bus
2020-05-09 Addresses 8-15
2020-05-09 Data Aquired
2020-05-09 Fixed 'Pad too close to Pad' Errors
2020-05-10 Finished Address Bus + Address and Data Bus Enables
2020-05-10 More Headers - 690 to 540 No-Connects
2020-05-10 Fixed 8255 Headers + Control Bus Header
2020-05-10 UART Connections + Some other Stuff
2020-05-10 Pals Hooked up to Address Bus
2020-05-10 Cool pt2
2020-05-10 addresses baby
2020-05-11 Wires are Hell
2020-05-11 Beep boop
2020-05-11 Oh lawd he comin
2020-05-11 shit
