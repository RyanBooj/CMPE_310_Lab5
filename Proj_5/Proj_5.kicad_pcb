# Repository RyanBooj/CMPE_310_Lab5

## KiCad design Proj_5/Proj_5.kicad_pcb

Notes on the sheet:
Ryan Bugianesi and Collin Mood

Parts:
C2: 0.1uF; CP_EIA-1608-08_AVX-J
CLK_Gen1: 8284 Clock; DIP-18_W7.62mm
CLK_R1, CLK_R2: 510 Ohm; R_1206_3216Metric
OSC1: 24 MHz Crystal OSC; Crystal_DS10_D1.0mm_L4.3mm_Horizontal

Connections:
/8086 and Demultiplexed Addresses/CLK: CLK_Gen1.8 (CLK); also elsewhere on the board
/8279, 8259, 8254/RESET: CLK_Gen1.11 (~RES~); also elsewhere on the board
/16550 UART/RESET: CLK_Gen1.10 (RESET); also elsewhere on the board
GND: C2.2, CLK_Gen1.1 (CSYNC), CLK_Gen1.3 (~AEN1~), CLK_Gen1.7 (~AEN2~), CLK_Gen1.9 (GND), CLK_Gen1.13 (F/~C~), CLK_R1.1, CLK_R2.1; also elsewhere on the board
unnamed: CLK_Gen1.16 (X2), CLK_R2.2, OSC1.2
unnamed: CLK_Gen1.17 (X1), CLK_R1.2, OSC1.1

Parts:
C16, C17: 0.1uF; CP_EIA-1608-08_AVX-J
U4, U12: 28F010
U13: PAL16L8; DIP-20_W7.62mm

Connections:
/A0: U12.12 (A0); also elsewhere on the board
/A1: U4.11 (A1), U12.11 (A1); also elsewhere on the board
/A2: U4.10 (A2), U12.10 (A2); also elsewhere on the board
/A3: U4.9 (A3), U12.9 (A3); also elsewhere on the board
/A4: U4.8 (A4), U12.8 (A4); also elsewhere on the board
/A5: U4.7 (A5), U12.7 (A5); also elsewhere on the board
/A6: U4.6 (A6), U12.6 (A6); also elsewhere on the board
/A7: U4.5 (A7), U12.5 (A7); also elsewhere on the board
/A8: U4.27 (A8), U12.27 (A8); also elsewhere on the board
/A9: U4.26 (A9), U12.26 (A9); also elsewhere on the board
/A10: U4.23 (A10), U12.23 (A10); also elsewhere on the board
/A11: U4.25 (A11), U12.25 (A11); also elsewhere on the board
/A12: U4.4 (A12), U12.4 (A12); also elsewhere on the board
/A13: U4.28 (A13), U12.28 (A13); also elsewhere on the board
/A14: U4.29 (A14), U12.29 (A14); also elsewhere on the board
/A15: U4.3 (A15), U12.3 (A15); also elsewhere on the board
/A16: U4.2 (A16), U12.2 (A16); also elsewhere on the board
/A17: U13.3 (I3); also elsewhere on the board
/A18: U13.2 (I2); also elsewhere on the board
/A19: U13.1 (I1); also elsewhere on the board
/D0: U12.13 (DQ0); also elsewhere on the board
/D1: U12.14 (DQ1); also elsewhere on the board
/D2: U12.15 (DQ2); also elsewhere on the board
/D3: U12.17 (DQ3); also elsewhere on the board
/D4: U12.18 (DQ4); also elsewhere on the board
/D5: U12.19 (DQ5); also elsewhere on the board
/D6: U12.20 (DQ6); also elsewhere on the board
/D7: U12.21 (DQ7); also elsewhere on the board
/D8: U4.13 (DQ0); also elsewhere on the board
/D9: U4.14 (DQ1); also elsewhere on the board
/D10: U4.15 (DQ2); also elsewhere on the board
/D11: U4.17 (DQ3); also elsewhere on the board
/D12: U4.18 (DQ4); also elsewhere on the board
/D13: U4.19 (DQ5); also elsewhere on the board
/D14: U4.20 (DQ6); also elsewhere on the board
/D15: U4.21 (DQ7); also elsewhere on the board
/M~IO: U13.4 (I4); also elsewhere on the board
/~BHE: U4.12 (A0); also elsewhere on the board
/~RD: U4.24 (OE), U12.24 (OE); also elsewhere on the board
/~WR: U4.31 (WE), U12.31 (WE); also elsewhere on the board
GND: C16.1, C17.1, U4.16 (VSS), U12.16 (VSS), U13.10 (GND); also elsewhere on the board
unnamed: U12.22 (CE), U13.18 (IO2)
unnamed: U4.22 (CE), U13.19 (IO1)

Notes on the sheet:
High Bank
Low Bank
Address Range: DFFFFh - FFFFFh (917503 - 1048575 dec)

Parts:
C7, C8, C9: 0.1uF; CP_EIA-1608-08_AVX-J
J1, J2, J3: Conn_02x15_Top_Bottom; PinHeader_2x15_P2.54mm_Vertical
U1, U2, U3: 8255; DIP-40_W15.24mm
U39, U40: PAL16L8; DIP-20_W7.62mm

Connections:
/16550 UART/RESET: U1.35 (RESET), U2.35 (RESET), U3.35 (RESET); also elsewhere on the board
/A0: U39.8 (I8); also elsewhere on the board
/A1: U39.7 (I7); also elsewhere on the board
/A2: U39.6 (I6); also elsewhere on the board
/A3: U39.5 (I5); also elsewhere on the board
/A4: U39.4 (I4); also elsewhere on the board
/A5: U39.3 (I3); also elsewhere on the board
/A6: U39.2 (I2); also elsewhere on the board
/A7: U39.1 (I1); also elsewhere on the board
/A8: U40.17 (I03); also elsewhere on the board
/A9: U40.18 (IO2); also elsewhere on the board
/A10: U40.11 (I10); also elsewhere on the board
/A11: U40.9 (I9); also elsewhere on the board
/A12: U40.8 (I8); also elsewhere on the board
/A13: U40.7 (I7); also elsewhere on the board
/A14: U40.6 (I6); also elsewhere on the board
/A15: U40.5 (I5); also elsewhere on the board
/A16: U40.4 (I4); also elsewhere on the board
/A17: U40.3 (I3); also elsewhere on the board
/A18: U40.2 (I2); also elsewhere on the board
/A19: U40.1 (I1); also elsewhere on the board
/D0: U1.34 (D0), U2.34 (D0), U3.34 (D0); also elsewhere on the board
/D1: U1.33 (D1), U2.33 (D1), U3.33 (D1); also elsewhere on the board
/D2: U1.32 (D2), U2.32 (D2), U3.32 (D2); also elsewhere on the board
/D3: U1.31 (D3), U2.31 (D3), U3.31 (D3); also elsewhere on the board
/D4: U1.30 (D4), U2.30 (D4), U3.30 (D4); also elsewhere on the board
/D5: U1.29 (D5), U2.29 (D5), U3.29 (D5); also elsewhere on the board
/D6: U1.28 (D6), U2.28 (D6), U3.28 (D6); also elsewhere on the board
/D7: U1.27 (D7), U2.27 (D7), U3.27 (D7); also elsewhere on the board
/M~IO: U39.9 (I9); also elsewhere on the board
/~RD: U1.5 (~RD~), U2.5 (~RD~), U3.5 (~RD~); also elsewhere on the board
/~WR: U1.36 (~WR~), U2.36 (~WR~), U3.36 (~WR~); also elsewhere on the board
GND: C7.1, C8.1, C9.1, U1.7 (GND), U2.7 (GND), U3.7 (GND), U39.10 (GND), U40.10 (GND); also elsewhere on the board
unnamed: J1.1, U1.4 (PA0)
unnamed: J1.2, U1.3 (PA1)
unnamed: J1.3, U1.2 (PA2)
unnamed: J1.4, U1.1 (PA3)
unnamed: J1.5, U1.40 (PA4)
unnamed: J1.6, U1.39 (PA5)
unnamed: J1.7, U1.38 (PA6)
unnamed: J1.8, U1.37 (PA7)
unnamed: J1.9, U1.18 (PB0)
unnamed: J1.10, U1.19 (PB1)
unnamed: J1.11, U1.20 (PB2)
unnamed: J1.12, U1.21 (PB3)
unnamed: J1.13, U1.22 (PB4)
unnamed: J1.14, U1.23 (PB5)
unnamed: J1.15, U1.24 (PB6)
unnamed: J1.16, U1.25 (PB7)
unnamed: J1.17, U1.14 (PC0)
unnamed: J1.18, U1.15 (PC1)
unnamed: J1.19, U1.16 (PC2)
unnamed: J1.20, U1.17 (PC3)
unnamed: J1.21, U1.13 (PC4)
unnamed: J1.22, U1.12 (PC5)
unnamed: J1.23, U1.11 (PC6)
unnamed: J1.24, U1.10 (PC7)
unnamed: J2.1, U3.4 (PA0)
unnamed: J2.2, U3.3 (PA1)
unnamed: J2.3, U3.2 (PA2)
unnamed: J2.4, U3.1 (PA3)
unnamed: J2.5, U3.40 (PA4)
unnamed: J2.6, U3.39 (PA5)
unnamed: J2.7, U3.38 (PA6)
unnamed: J2.8, U3.37 (PA7)
unnamed: J2.9, U3.18 (PB0)
unnamed: J2.10, U3.19 (PB1)
unnamed: J2.11, U3.20 (PB2)
unnamed: J2.12, U3.21 (PB3)
unnamed: J2.13, U3.22 (PB4)
unnamed: J2.14, U3.23 (PB5)
unnamed: J2.15, U3.24 (PB6)
unnamed: J2.16, U3.25 (PB7)
unnamed: J2.17, U3.14 (PC0)
unnamed: J2.18, U3.15 (PC1)
unnamed: J2.19, U3.16 (PC2)
unnamed: J2.20, U3.17 (PC3)
unnamed: J2.21, U3.13 (PC4)
unnamed: J2.22, U3.12 (PC5)
unnamed: J2.23, U3.11 (PC6)
unnamed: J2.24, U3.10 (PC7)
unnamed: J3.1, U2.4 (PA0)
unnamed: J3.2, U2.3 (PA1)
unnamed: J3.3, U2.2 (PA2)
unnamed: J3.4, U2.1 (PA3)
unnamed: J3.5, U2.40 (PA4)
unnamed: J3.6, U2.39 (PA5)
unnamed: J3.7, U2.38 (PA6)
unnamed: J3.8, U2.37 (PA7)
unnamed: J3.9, U2.18 (PB0)
unnamed: J3.10, U2.19 (PB1)
unnamed: J3.11, U2.20 (PB2)
unnamed: J3.12, U2.21 (PB3)
unnamed: J3.13, U2.22 (PB4)
unnamed: J3.14, U2.23 (PB5)
unnamed: J3.15, U2.24 (PB6)
unnamed: J3.16, U2.25 (PB7)
unnamed: J3.17, U2.14 (PC0)
unnamed: J3.18, U2.15 (PC1)
unnamed: J3.19, U2.16 (PC2)
unnamed: J3.20, U2.17 (PC3)
unnamed: J3.21, U2.13 (PC4)
unnamed: J3.22, U2.12 (PC5)
unnamed: J3.23, U2.11 (PC6)
unnamed: J3.24, U2.10 (PC7)
unnamed: U1.6 (~CS~), U2.6 (~CS~), U3.6 (~CS~), U39.17 (I03)
unnamed: U1.8 (A1), U2.8 (A1), U3.8 (A1), U39.18 (IO2)
unnamed: U1.9 (A0), U2.9 (A0), U3.9 (A0), U39.19 (IO1)
unnamed: U39.11 (I10), U40.19 (IO1)

Parts:
C11, C12, C13, C15, C18, C19: 0.1uF; CP_EIA-1608-08_AVX-J
J4: Conn_02x07_Counter_Clockwise; PinHeader_2x07_P1.00mm_Vertical
J5: Conn_02x04_Top_Bottom; PinHeader_2x04_P1.00mm_Vertical
R17: 1kOhm; R_0201_0603Metric
SW2: Shift; SW_SPST_B3U-1000P-B
SW3, SW4, SW5, SW6, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23: Switch_SW_SPST; SW_SPST_B3U-1000P-B
SW7: CTRL; SW_SPST_B3U-1000P-B
SW24: NMI Button; SW_SPST_B3U-1000P-B
SW25: Reset Button; SW_SPST_B3U-1000P-B
SW26: IR0 Button; SW_SPST_B3U-1000P-B
U10: 8259; DIP-28_W15.24mm
U11: 8254; DIP-24_W15.24mm
U17: pkd8279
U18: 74LS138; DIP-16_W7.62mm
U35, U38: PAL16L8; DIP-20_W7.62mm
U48, U49, U50: MAX6816; SOT-143

Connections:
/8086 and Demultiplexed Addresses/CLK: U17.3 (CLK); also elsewhere on the board
/8279, 8259, 8254/INT: U10.17 (INT); also elsewhere on the board
/8279, 8259, 8254/NMI: U48.3 (OUT); also elsewhere on the board
/8279, 8259, 8254/RESET: U17.9 (RESET), U49.3 (OUT); also elsewhere on the board
/8279, 8259, 8254/~INTA: U10.26 (~INTA~); also elsewhere on the board
/16550 UART/IR3: U10.21 (IR3); also elsewhere on the board
/A0: U38.8 (I8); also elsewhere on the board
/A1: U38.7 (I7); also elsewhere on the board
/A2: U38.6 (I6); also elsewhere on the board
/A3: U38.5 (I5); also elsewhere on the board
/A4: U38.4 (I4); also elsewhere on the board
/A5: U38.3 (I3); also elsewhere on the board
/A6: U38.2 (I2); also elsewhere on the board
/A7: U38.1 (I1); also elsewhere on the board
/A8: U35.17 (I03); also elsewhere on the board
/A9: U35.18 (IO2); also elsewhere on the board
/A10: U35.11 (I10); also elsewhere on the board
/A11: U35.9 (I9); also elsewhere on the board
/A12: U35.8 (I8); also elsewhere on the board
/A13: U35.7 (I7); also elsewhere on the board
/A14: U35.6 (I6); also elsewhere on the board
/A15: U35.5 (I5); also elsewhere on the board
/A16: U35.4 (I4); also elsewhere on the board
/A17: U35.3 (I3); also elsewhere on the board
/A18: U35.2 (I2); also elsewhere on the board
/A19: U35.1 (I1); also elsewhere on the board
/D0: U10.11 (D0), U11.8 (D0), U17.12 (DB0); also elsewhere on the board
/D1: U10.10 (D1), U11.7 (D1), U17.13 (DB1); also elsewhere on the board
/D2: U10.9 (D2), U11.6 (D2), U17.14 (DB2); also elsewhere on the board
/D3: U10.8 (D3), U11.5 (D3), U17.15 (DB3); also elsewhere on the board
/D4: U10.7 (D4), U11.4 (D4), U17.16 (DB4); also elsewhere on the board
/D5: U10.6 (D5), U11.3 (D5), U17.17 (DB5); also elsewhere on the board
/D6: U10.5 (D6), U11.2 (D6), U17.18 (DB6); also elsewhere on the board
/D7: U10.4 (D7), U11.1 (D7), U17.19 (DB7); also elsewhere on the board
/~RD: U10.3 (~RD~), U11.22 (~RD~), U17.10 (~RD); also elsewhere on the board
/~WR: U10.2 (~WR~), U11.23 (~WR~), U17.11 (~WR); also elsewhere on the board
GND: C11.2, C12.2, C13.1, C15.2, C18.2, C19.2, U10.14 (GND), U11.12 (GND), U17.20 (VSS), U18.4 (E1), U18.5 (E2), U18.8 (GND), U35.10 (GND), U38.10 (GND), U48.1 (GND), U49.1 (GND), U50.1 (GND); also elsewhere on the board
unnamed: J4.1, U11.9 (CLK0)
unnamed: J4.4, U11.15 (CLK1)
unnamed: J4.5, U11.14 (G1)
unnamed: J4.6, U11.13 (OUT1)
unnamed: J4.7, U11.18 (CLK2)
unnamed: J4.8, U11.16 (G2)
unnamed: J5.1, U10.22 (IR4)
unnamed: J5.3, U10.23 (IR5)
unnamed: J5.5, U10.24 (IR6)
unnamed: J5.7, U10.25 (IR7)
unnamed: R17.1, U18.6 (E3)
unnamed: SW2.1 (A), U17.36 (SHIFT)
unnamed: SW2.2 (B), SW3.2 (B), SW4.2 (B), SW5.2 (B), SW6.2 (B), U18.15 (O0)
unnamed: SW7.1 (A), U17.37 (CNTL/STB)
unnamed: SW5.1 (A), SW10.1 (A), SW14.1 (A), SW18.1 (A), SW22.1 (A), U17.1 (RL2)
unnamed: SW7.2 (B), SW8.2 (B), SW9.2 (B), SW10.2 (B), SW11.2 (B), U18.14 (O1)
unnamed: SW6.1 (A), SW11.1 (A), SW15.1 (A), SW19.1 (A), SW23.1 (A), U17.2 (RL3)
unnamed: SW3.1 (A), SW8.1 (A), SW12.1 (A), SW16.1 (A), SW20.1 (A), U17.38 (RL0)
unnamed: SW12.2 (B), SW13.2 (B), SW14.2 (B), SW15.2 (B), SW24.2 (B), U18.13 (O2)
unnamed: SW4.1 (A), SW9.1 (A), SW13.1 (A), SW17.1 (A), SW21.1 (A), U17.39 (RL1)
unnamed: SW16.2 (B), SW17.2 (B), SW18.2 (B), SW19.2 (B), SW25.2 (B), U18.12 (O3)
unnamed: SW20.2 (B), SW21.2 (B), SW22.2 (B), SW23.2 (B), SW26.2 (B), U18.11 (O4)
unnamed: SW24.1 (A), U48.2 (IN)
unnamed: SW25.1 (A), U49.2 (IN)
unnamed: SW26.1 (A), U50.2 (IN)
unnamed: U10.1 (~CS~), U38.19 (IO1)
unnamed: U10.18 (IR0), U50.3 (OUT)
unnamed: U10.19 (IR1), U11.17 (OUT2)
unnamed: U10.20 (IR2), U17.4 (IRQ)
unnamed: U10.27 (A0), U38.18 (IO2)
unnamed: U11.19 (A0), U38.14 (IO6)
unnamed: U11.20 (A1), U38.13 (IO7)
unnamed: U11.21 (~CS~), U38.15 (IO5)
unnamed: U17.21 (A0), U38.16 (IO4)
unnamed: U17.22 (~CS), U38.17 (I03)
unnamed: U17.32 (SL0), U18.1 (A0)
unnamed: U17.33 (SL1), U18.2 (A1)
unnamed: U17.34 (SL2), U18.3 (A2)
unnamed: U35.19 (IO1), U38.11 (I10)

Notes on the sheet:
Needs: Decoding

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
